# Keil uVision project STM32_GRBl_Advanced.uvprojx, settings and files
target STM32_GRBl_Advanced (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_GRBl_Advanced +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Hardware\grbl;..\Hardware\grbl\HAL;..\Hardware\grbl\HAL\Debug;..\Hardware\Global
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Hardware/Grbl
    ../Hardware/grbl/: CoolantControl.c GCode.c Jog.c Limits.c MotionControl.c Planner.c Probe.c Protocol.c Report.c Settings.c SpindleControl.c Stepper.c System.c util.c defaults.h
  group Hardware/Grbl/HAL
    ../Hardware/grbl/HAL/: eeprom.c FIFO_USART.c HW_USART.c System32.c HW_GPIO.c HW_TIM.c
    ../Hardware/grbl/HAL/Debug/: Print.c
  group Global
    ../Hardware/Global/: Global.c Motor_setting.c Arm_motion.c
software components: CMSIS:CORE 4.3.0
